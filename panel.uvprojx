# Keil uVision project panel.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MDR1986BE92 Milandr
  pack: Keil.MDR1986BExx.1.5.2
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Panel
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_MDR32F9Q2_Rev1
  c misc: --cpp11
  c include: .\User;.\Interrupt;.\LedInd;..\CPP_lib\Port;..\CPP_lib\Timer;..\CPP_lib\Delay;..\CPP_lib\RCC;..\CPP_lib\UART;..\CPP_lib\spi
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ./User/: HAL.cpp HAL.h main.cpp portDefenition.h
  group Interrupt
    ./Interrupt/: MDR32F9Qx_it.c MDR32F9Qx_it.h
  group LedInd
    ./LedInd/: ledInd.cpp ledInd.h
  group Port
    ../CPP_lib/Port/: port.cpp port.h
  group Timer
    ../CPP_lib/Timer/: timer.cpp timer.h
  group Delay
    ../CPP_lib/Delay/: delay.cpp delay.h
  group Rcc
    ../CPP_lib/RCC/: RCC.cpp RCC.h
  group Uart
    ../CPP_lib/UART/: uart.cpp uart.h
  group SPI
    ../CPP_lib/spi/: spi.cpp spi.h
software components: Device:Startup 1.5, Drivers:PORT 1.5, Drivers:RST_CLK 1.5, Drivers:SSP 1.5, Drivers:TIMER 1.5, Drivers:UART 1.5
